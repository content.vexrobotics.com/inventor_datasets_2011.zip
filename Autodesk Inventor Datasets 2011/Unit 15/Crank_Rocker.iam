# Autodesk Inventor assembly: Crank_Rocker
## iProperties
Created: 2008-04
Part Number: Crank_Rocker
Document SubType Name: Assembly
