# Autodesk Inventor assembly: TankTread
## iProperties
Created: 2008-04
Part Number: TankTread
Document SubType Name: Assembly
