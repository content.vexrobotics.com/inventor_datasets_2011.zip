# Autodesk Inventor part: NUT-832-NYLOCK
## iProperties
Created: 2007-10
Part Number: NUT-832-NYLOCK
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
