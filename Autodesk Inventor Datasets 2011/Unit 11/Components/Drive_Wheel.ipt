# Autodesk Inventor part: Drive_Wheel
## iProperties
Created: 2007-09
Part Number: Drive_Wheel
Material: ABS Plastic
Document SubType Name: Modeling
Density: 1.06 g/cm^3
