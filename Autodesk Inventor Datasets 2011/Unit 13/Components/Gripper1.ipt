# Autodesk Inventor part: Gripper1
## iProperties
Created: 2008-05
Part Number: Gripper1
Document SubType Name: Modeling
Density: 1 g/cm^3
