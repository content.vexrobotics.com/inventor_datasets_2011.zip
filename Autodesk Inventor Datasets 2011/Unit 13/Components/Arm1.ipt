# Autodesk Inventor part: Arm1
## iProperties
Created: 2008-05
Part Number: Arm1
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Rectangular Pattern1
