# Autodesk Inventor part: BEAM-1000
## iProperties
Created: 2007-08
Part Number: BEAM-1000
Material: Aluminum-6061
Document SubType Name: Modeling
Density: 2.71 g/cm^3
## Feature names
1. Base1
