# Autodesk Inventor assembly: MICROCONTROLLER-PCB
## iProperties
Created: 2008-06
Document SubType Name: Assembly
